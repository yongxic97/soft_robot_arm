# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Source\APP;..\Source\STM32F10xLib\inc;..\Source\STM32F10xLib\M3;..\Source\Drive;..\Source\STM32F10xLib\startup;..\Source\Drive;F:\MDK5\MDK5\ARM\CMSIS\4.5.0\CMSIS\Include;..\Source\Drive\TIMER;..\Source\Drive\LED;..\Source\Drive\KEY;..\Source\Drive\ADC;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../Source/APP/: Main.c
  group DRIVER
    ../Source/Drive/: delay.c UART1.c UART2.c DIO.c UART3.c sys.c bsp_spi_ad7606 .c bsp_spi_ad7606_2.c bsp_mcp23017.c bsp_mcp23017_2.c
    ../Source/Drive/TIMER/: timer.c
    ../Source/Drive/KEY/: key.c
    ../Source/Drive/ADC/: adc.c
  group FWLib
    ../Source/STM32F10xLib/M3/: system_stm32f10x.c
    ../Source/STM32F10xLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c
    ../Source/STM32F10xLib/startup/: startup_stm32f10x_md.s
software components: CMSIS:CORE 5.4.0
